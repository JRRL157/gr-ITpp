options:
  parameters:
    generate_options: qt_gui
    id: BER_Simulation_2
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: K
  id: variable
  parameters:
    value: '4'
  states: {}
- name: N
  id: variable
  parameters:
    value: '7'
  states: {}
- name: amp
  id: variable
  parameters:
    value: amp_range[0]
  states: {state: disabled}
- name: amp_range
  id: variable
  parameters:
    value: numpy.sqrt(2)*10**((ec_n0_db_range/20.0))
  states: {state: disabled}
- name: ec_n0_db_range
  id: variable
  parameters:
    value: numpy.arange(min_Ec_N0_dB,max_Ec_N0_dB,step_Ec_N0_dB)
  states: {state: disabled}
- name: m
  id: variable
  parameters:
    value: N-K
  states: {}
- name: max_Ec_N0_dB
  id: variable
  parameters:
    value: max_Eb_N0_dB - 10*log10(N/K)
  states: {}
- name: min_Ec_N0_dB
  id: variable
  parameters:
    value: min_Eb_N0_dB - 10*log10(N/K)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '3200000'
  states: {}
- name: step_Ec_N0_dB
  id: variable
  parameters:
    value: step_Eb_N0_dB
  states: {}
- name: ITpp_BER_Analyzer_0
  id: ITpp_BER_Analyzer
  parameters:
    init_Eb_N0_dB: '0'
    max_Eb_N0_dB: '11.0'
    step_Eb_N0_dB: '1.0'
  states: {}
- name: ITpp_Hamming_Decoder_0
  id: ITpp_Hamming_Decoder
  parameters:
    m: m
  states: {}
- name: ITpp_Hamming_Encoder_0
  id: ITpp_Hamming_Encoder
  parameters:
    m: m
  states: {}
- name: ITpp_Hamming_Soft_Decoder_0
  id: ITpp_Hamming_Soft_Decoder
  parameters:
    m: m
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '7'
    type: int
  states: {}
- name: analog_const_source_x_0_0
  id: analog_const_source_x
  parameters:
    const: '4'
    type: int
  states: {}
- name: analog_const_source_x_0_0_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: float
  states: {}
- name: analog_const_source_x_0_0_0_0
  id: analog_const_source_x
  parameters:
    const: '10'
    type: float
  states: {}
- name: analog_const_source_x_0_0_0_0_0
  id: analog_const_source_x
  parameters:
    const: '0.1'
    type: float
  states: {}
- name: analog_const_source_x_1
  id: analog_const_source_x
  parameters:
    const: np.random.choice(2,10000)
    type: byte
  states: {state: disabled}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '2'
    min: '0'
    num_samps: '2000000'
    repeat: 'True'
    type: byte
  states: {}
- name: analog_random_uniform_source_x_0
  id: analog_random_uniform_source_x
  parameters:
    maximum: '2'
    minimum: '0'
    seed: '7'
    type: byte
  states: {state: disabled}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: blocks_add_xx_1
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '0.5'
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: blocks_uchar_to_float_0_1
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_uchar_to_float_0_1_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_uchar_to_float_0_1_0_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_uchar_to_float_1
  id: blocks_uchar_to_float
  parameters: {}
  states: {state: disabled}
- name: import_0
  id: import
  parameters:
    imports: from math import log10
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: max_Eb_N0_dB
  id: parameter
  parameters:
    value: '10'
  states: {}
- name: min_Eb_N0_dB
  id: parameter
  parameters:
    value: '0'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    label1: Sinal de ruído
    label2: Eb/N0(dB)
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_1
  id: qtgui_time_sink_x
  parameters:
    color1: green
    grid: 'True'
    label1: Enviado
    marker1: '0'
    size: '64'
    srate: '320000'
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    label2: Hard Decoding
    label3: Soft Decoding
    marker2: '0'
    marker3: '1'
    nconnections: '3'
    size: '16'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_1_0
  id: qtgui_time_sink_x
  parameters:
    label1: Soft Decoding
    label2: Hard Decoding
    label3: ' Message'
    marker1: '0'
    marker2: '0'
    marker3: '2'
    nconnections: '3'
    size: '64'
    srate: samp_rate
    stemplot: 'True'
    style3: '3'
    type: float
    ymax: '3'
    ymin: '0'
  states: {}
- name: step_Eb_N0_dB
  id: parameter
  parameters:
    value: '1'
  states: {}
- name: testing_HardReceiver_0
  id: testing_HardReceiver
  parameters: {}
  states: {}
- name: testing_NoiseConverter_0
  id: testing_NoiseConverter
  parameters: {}
  states: {}

connections:
- [ITpp_BER_Analyzer_0, '0', qtgui_time_sink_x_1, '0']
- [ITpp_BER_Analyzer_0, '1', qtgui_time_sink_x_1, '1']
- [ITpp_BER_Analyzer_0, '2', qtgui_time_sink_x_1, '2']
- [ITpp_Hamming_Decoder_0, '0', ITpp_BER_Analyzer_0, '2']
- [ITpp_Hamming_Decoder_0, '0', blocks_uchar_to_float_0_1_0, '0']
- [ITpp_Hamming_Encoder_0, '0', blocks_char_to_float_0, '0']
- [ITpp_Hamming_Soft_Decoder_0, '0', ITpp_BER_Analyzer_0, '3']
- [ITpp_Hamming_Soft_Decoder_0, '0', blocks_uchar_to_float_0_1, '0']
- [analog_const_source_x_0, '0', testing_NoiseConverter_0, '0']
- [analog_const_source_x_0_0, '0', testing_NoiseConverter_0, '1']
- [analog_const_source_x_0_0_0, '0', testing_NoiseConverter_0, '2']
- [analog_const_source_x_0_0_0_0, '0', testing_NoiseConverter_0, '3']
- [analog_const_source_x_0_0_0_0_0, '0', testing_NoiseConverter_0, '4']
- [analog_const_source_x_1, '0', blocks_throttle_0, '0']
- [analog_random_source_x_0, '0', blocks_throttle_0, '0']
- [analog_random_uniform_source_x_0, '0', blocks_throttle_0, '0']
- [blocks_add_const_vxx_0, '0', blocks_add_xx_1, '0']
- [blocks_add_xx_1, '0', ITpp_Hamming_Soft_Decoder_0, '0']
- [blocks_add_xx_1, '0', testing_HardReceiver_0, '0']
- [blocks_char_to_float_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_throttle_0, '0', ITpp_BER_Analyzer_0, '1']
- [blocks_throttle_0, '0', ITpp_Hamming_Encoder_0, '0']
- [blocks_throttle_0, '0', blocks_uchar_to_float_0_1_0_0, '0']
- [blocks_throttle_0, '0', blocks_uchar_to_float_1, '0']
- [blocks_uchar_to_float_0_1, '0', qtgui_time_sink_x_1_0, '0']
- [blocks_uchar_to_float_0_1_0, '0', qtgui_time_sink_x_1_0, '1']
- [blocks_uchar_to_float_0_1_0_0, '0', qtgui_time_sink_x_1_0, '2']
- [blocks_uchar_to_float_1, '0', qtgui_time_sink_x_0_1, '0']
- [testing_HardReceiver_0, '0', ITpp_Hamming_Decoder_0, '0']
- [testing_NoiseConverter_0, '0', blocks_add_xx_1, '1']
- [testing_NoiseConverter_0, '0', qtgui_time_sink_x_0, '0']
- [testing_NoiseConverter_0, '1', ITpp_BER_Analyzer_0, '0']
- [testing_NoiseConverter_0, '1', qtgui_time_sink_x_0, '1']

metadata:
  file_format: 1
