options:
  parameters:
    generate_options: qt_gui
    id: BER_Simulation
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: K
  id: variable
  parameters:
    value: '4'
  states: {}
- name: N
  id: variable
  parameters:
    value: '7'
  states: {}
- name: m
  id: variable
  parameters:
    value: N-K
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '3200000'
  states: {}
- name: ITpp_BER_Analyzer_cpp_0
  id: ITpp_BER_Analyzer_cpp
  parameters: {}
  states: {}
- name: ITpp_Hamming_Decoder_0
  id: ITpp_Hamming_Decoder
  parameters:
    m: m
  states: {}
- name: ITpp_Hamming_Encoder_0
  id: ITpp_Hamming_Encoder
  parameters:
    m: m
  states: {}
- name: ITpp_Hamming_Soft_Decoder_0
  id: ITpp_Hamming_Soft_Decoder
  parameters:
    m: m
  states: {}
- name: ITpp_Hard_Receiver_0
  id: ITpp_Hard_Receiver
  parameters: {}
  states: {state: disabled}
- name: ITpp_NoiseGenerator_0
  id: ITpp_NoiseGenerator
  parameters: {}
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '7'
    type: int
  states: {}
- name: analog_const_source_x_0_0
  id: analog_const_source_x
  parameters:
    const: '4'
    type: int
  states: {}
- name: analog_const_source_x_0_0_0
  id: analog_const_source_x
  parameters:
    const: '1'
    type: float
  states: {}
- name: analog_const_source_x_0_0_0_0
  id: analog_const_source_x
  parameters:
    const: '7'
    type: float
  states: {}
- name: analog_const_source_x_0_0_0_0_0
  id: analog_const_source_x
  parameters:
    const: '0.01'
    type: float
  states: {}
- name: analog_const_source_x_1
  id: analog_const_source_x
  parameters:
    const: '-1'
    type: float
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '2'
    min: '0'
    num_samps: '10000000'
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: blocks_add_xx_0_1
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_add_xx_0_1_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_add_xx_1
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '0.5'
  states: {}
- name: blocks_int_to_float_0
  id: blocks_int_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_int_to_float_0_0
  id: blocks_int_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_int_to_float_0_0_0
  id: blocks_int_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_uchar_to_float_0_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_uchar_to_float_1
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from math import log10
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    label1: Sinal de ruído
    label2: Eb/N0(dB)
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_1_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    label1: Soft Decoding
    label2: Hard Decoding
    label3: Uncoded - Theory
    marker1: '0'
    marker2: '1'
    marker3: '0'
    nconnections: '3'
    size: '1024'
    srate: samp_rate
    stemplot: 'True'
    style1: '3'
    style2: '3'
    style3: '3'
    type: float
    ymax: '3'
    ymin: '0'
  states: {}

connections:
- [ITpp_BER_Analyzer_cpp_0, '0', blocks_int_to_float_0, '0']
- [ITpp_BER_Analyzer_cpp_0, '1', blocks_int_to_float_0_0, '0']
- [ITpp_BER_Analyzer_cpp_0, '2', blocks_int_to_float_0_0_0, '0']
- [ITpp_Hamming_Decoder_0, '0', blocks_uchar_to_float_0_0, '0']
- [ITpp_Hamming_Encoder_0, '0', blocks_char_to_float_0, '0']
- [ITpp_Hamming_Soft_Decoder_0, '0', blocks_uchar_to_float_0, '0']
- [ITpp_Hard_Receiver_0, '0', ITpp_Hamming_Decoder_0, '0']
- [ITpp_NoiseGenerator_0, '0', blocks_add_xx_1, '0']
- [ITpp_NoiseGenerator_0, '0', qtgui_time_sink_x_0, '0']
- [ITpp_NoiseGenerator_0, '1', ITpp_BER_Analyzer_cpp_0, '0']
- [ITpp_NoiseGenerator_0, '1', qtgui_time_sink_x_0, '1']
- [analog_const_source_x_0, '0', ITpp_NoiseGenerator_0, '0']
- [analog_const_source_x_0_0, '0', ITpp_NoiseGenerator_0, '1']
- [analog_const_source_x_0_0_0, '0', ITpp_NoiseGenerator_0, '2']
- [analog_const_source_x_0_0_0_0, '0', ITpp_NoiseGenerator_0, '3']
- [analog_const_source_x_0_0_0_0_0, '0', ITpp_NoiseGenerator_0, '4']
- [analog_const_source_x_1, '0', blocks_multiply_xx_0, '1']
- [analog_const_source_x_1, '0', blocks_multiply_xx_0_0, '0']
- [analog_random_source_x_0, '0', blocks_throttle_0, '0']
- [blocks_add_const_vxx_0, '0', blocks_add_xx_1, '1']
- [blocks_add_xx_0_1, '0', ITpp_BER_Analyzer_cpp_0, '1']
- [blocks_add_xx_0_1_0, '0', ITpp_BER_Analyzer_cpp_0, '2']
- [blocks_add_xx_1, '0', ITpp_Hamming_Soft_Decoder_0, '0']
- [blocks_add_xx_1, '0', ITpp_Hard_Receiver_0, '0']
- [blocks_add_xx_1, '0', digital_binary_slicer_fb_0, '0']
- [blocks_char_to_float_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_int_to_float_0, '0', qtgui_time_sink_x_1_0, '0']
- [blocks_int_to_float_0_0, '0', qtgui_time_sink_x_1_0, '1']
- [blocks_int_to_float_0_0_0, '0', qtgui_time_sink_x_1_0, '2']
- [blocks_multiply_xx_0, '0', blocks_add_xx_0_1, '1']
- [blocks_multiply_xx_0_0, '0', blocks_add_xx_0_1_0, '1']
- [blocks_throttle_0, '0', ITpp_Hamming_Encoder_0, '0']
- [blocks_throttle_0, '0', blocks_uchar_to_float_1, '0']
- [blocks_uchar_to_float_0, '0', blocks_multiply_xx_0, '0']
- [blocks_uchar_to_float_0_0, '0', blocks_multiply_xx_0_0, '1']
- [blocks_uchar_to_float_1, '0', blocks_add_xx_0_1, '0']
- [blocks_uchar_to_float_1, '0', blocks_add_xx_0_1_0, '0']
- [digital_binary_slicer_fb_0, '0', ITpp_Hamming_Decoder_0, '0']

metadata:
  file_format: 1
