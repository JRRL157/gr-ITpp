options:
  parameters:
    generate_options: qt_gui
    id: default
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '320000'
  states: {}
- name: ITpp_BER_Analyzer_0
  id: ITpp_BER_Analyzer
  parameters:
    Eb_N0_dB: '10'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '7'
    type: int
  states: {}
- name: analog_const_source_x_0_0
  id: analog_const_source_x
  parameters:
    const: '4'
    type: int
  states: {}
- name: analog_const_source_x_0_1
  id: analog_const_source_x
  parameters:
    const: '1000'
    type: int
  states: {}
- name: blocks_packed_to_unpacked_xx_0
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: '4'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_vector_source_x_0_0_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: (1, 1,0,0)
  states: {}
- name: blocks_vector_source_x_0_0_1
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: (0, 1,0,0)
  states: {}
- name: blocks_vector_source_x_0_0_2
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: (0, 0,0,1)
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: '256'
    srate: samp_rate
    type: float
  states: {}

connections:
- [ITpp_BER_Analyzer_0, '0', blocks_throttle_0, '0']
- [analog_const_source_x_0, '0', ITpp_BER_Analyzer_0, '0']
- [analog_const_source_x_0_0, '0', ITpp_BER_Analyzer_0, '1']
- [analog_const_source_x_0_1, '0', ITpp_BER_Analyzer_0, '2']
- [blocks_packed_to_unpacked_xx_0, '0', blocks_uchar_to_float_0, '0']
- [blocks_throttle_0, '0', blocks_packed_to_unpacked_xx_0, '0']
- [blocks_uchar_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_vector_source_x_0_0_0, '0', ITpp_BER_Analyzer_0, '3']
- [blocks_vector_source_x_0_0_1, '0', ITpp_BER_Analyzer_0, '4']
- [blocks_vector_source_x_0_0_2, '0', ITpp_BER_Analyzer_0, '5']

metadata:
  file_format: 1
