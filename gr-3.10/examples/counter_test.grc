options:
  parameters:
    generate_options: qt_gui
    id: counter_test
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '320000'
  states: {}
- name: ITpp_counter_0
  id: ITpp_counter
  parameters: {}
  states: {}
- name: analog_const_source_x_0_0
  id: analog_const_source_x
  parameters:
    const: '7'
    type: byte
  states: {}
- name: analog_const_source_x_0_0_0
  id: analog_const_source_x
  parameters:
    const: '1'
    type: byte
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: (0)
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    marker1: '0'
    size: '64'
    srate: samp_rate
    type: float
  states: {}

connections:
- [ITpp_counter_0, '0', blocks_uchar_to_float_0, '0']
- [analog_const_source_x_0_0, '0', ITpp_counter_0, '2']
- [analog_const_source_x_0_0_0, '0', ITpp_counter_0, '1']
- [blocks_throttle_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_uchar_to_float_0, '0', blocks_throttle_0, '0']
- [blocks_vector_source_x_0, '0', ITpp_counter_0, '0']

metadata:
  file_format: 1
