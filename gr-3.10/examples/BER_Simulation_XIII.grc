options:
  parameters:
    generate_options: qt_gui
    id: BER_Simulation_XIII
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: B
  id: variable
  parameters:
    value: samp_rate/2
  states: {}
- name: K
  id: variable
  parameters:
    value: '4'
  states: {}
- name: N
  id: variable
  parameters:
    value: '7'
  states: {}
- name: amp
  id: variable
  parameters:
    value: (1.0/numpy.sqrt(2.0)) * 10.0 ** (-esno/ 20.0)
  states: {}
- name: ebn0_db
  id: variable
  parameters:
    value: numpy.arange(0, 10, 1)
  states: {}
- name: esno
  id: variable
  parameters:
    value: ebn0_db - 10*log10(N/K)
  states: {}
- name: m
  id: variable
  parameters:
    value: N-K
  states: {}
- name: num_curves
  id: variable
  parameters:
    value: '3'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '3200000'
  states: {}
- name: ITpp_Decoder_BPSK_0
  id: ITpp_Decoder_BPSK
  parameters:
    m: '3'
  states: {}
- name: ITpp_Decoder_BPSK_0_0
  id: ITpp_Decoder_BPSK
  parameters:
    m: '3'
  states: {}
- name: ITpp_Decoder_BPSK_0_1
  id: ITpp_Decoder_BPSK
  parameters:
    m: '3'
  states: {}
- name: ITpp_Decoder_BPSK_0_2
  id: ITpp_Decoder_BPSK
  parameters:
    m: '3'
  states: {}
- name: ITpp_Decoder_BPSK_0_3
  id: ITpp_Decoder_BPSK
  parameters:
    m: '3'
  states: {}
- name: ITpp_Decoder_BPSK_0_4
  id: ITpp_Decoder_BPSK
  parameters:
    m: '3'
  states: {}
- name: ITpp_Decoder_BPSK_0_5
  id: ITpp_Decoder_BPSK
  parameters:
    m: '3'
  states: {}
- name: ITpp_Decoder_BPSK_0_6
  id: ITpp_Decoder_BPSK
  parameters:
    m: '3'
  states: {}
- name: ITpp_Decoder_BPSK_0_7
  id: ITpp_Decoder_BPSK
  parameters:
    m: '3'
  states: {}
- name: ITpp_Decoder_BPSK_0_8
  id: ITpp_Decoder_BPSK
  parameters:
    m: '3'
  states: {}
- name: ITpp_Hamming_Decoder_0
  id: ITpp_Hamming_Decoder
  parameters:
    m: m
  states: {}
- name: ITpp_Hamming_Decoder_0_0
  id: ITpp_Hamming_Decoder
  parameters:
    m: m
  states: {}
- name: ITpp_Hamming_Decoder_0_0_0
  id: ITpp_Hamming_Decoder
  parameters:
    m: m
  states: {}
- name: ITpp_Hamming_Decoder_0_0_1
  id: ITpp_Hamming_Decoder
  parameters:
    m: m
  states: {}
- name: ITpp_Hamming_Decoder_0_0_1_0
  id: ITpp_Hamming_Decoder
  parameters:
    m: m
  states: {}
- name: ITpp_Hamming_Decoder_0_0_1_1
  id: ITpp_Hamming_Decoder
  parameters:
    m: m
  states: {}
- name: ITpp_Hamming_Decoder_0_0_1_2
  id: ITpp_Hamming_Decoder
  parameters:
    m: m
  states: {}
- name: ITpp_Hamming_Decoder_0_0_1_3
  id: ITpp_Hamming_Decoder
  parameters:
    m: m
  states: {}
- name: ITpp_Hamming_Decoder_0_0_1_4
  id: ITpp_Hamming_Decoder
  parameters:
    m: m
  states: {}
- name: ITpp_Hamming_Decoder_0_0_1_5
  id: ITpp_Hamming_Decoder
  parameters:
    m: m
  states: {}
- name: ITpp_Hamming_Encoder_0
  id: ITpp_Hamming_Encoder
  parameters:
    m: m
  states: {}
- name: ITpp_Hamming_Soft_Decoder_0
  id: ITpp_Hamming_Soft_Decoder
  parameters:
    m: m
  states: {}
- name: ITpp_Hamming_Soft_Decoder_0_0
  id: ITpp_Hamming_Soft_Decoder
  parameters:
    m: m
  states: {}
- name: ITpp_Hamming_Soft_Decoder_0_0_0
  id: ITpp_Hamming_Soft_Decoder
  parameters:
    m: m
  states: {}
- name: ITpp_Hamming_Soft_Decoder_0_0_1
  id: ITpp_Hamming_Soft_Decoder
  parameters:
    m: m
  states: {}
- name: ITpp_Hamming_Soft_Decoder_0_0_1_0
  id: ITpp_Hamming_Soft_Decoder
  parameters:
    m: m
  states: {}
- name: ITpp_Hamming_Soft_Decoder_0_0_1_1
  id: ITpp_Hamming_Soft_Decoder
  parameters:
    m: m
  states: {}
- name: ITpp_Hamming_Soft_Decoder_0_0_1_2
  id: ITpp_Hamming_Soft_Decoder
  parameters:
    m: m
  states: {}
- name: ITpp_Hamming_Soft_Decoder_0_0_1_3
  id: ITpp_Hamming_Soft_Decoder
  parameters:
    m: m
  states: {}
- name: ITpp_Hamming_Soft_Decoder_0_0_1_4
  id: ITpp_Hamming_Soft_Decoder
  parameters:
    m: m
  states: {}
- name: ITpp_Hamming_Soft_Decoder_0_0_1_5
  id: ITpp_Hamming_Soft_Decoder
  parameters:
    m: m
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: amp[0]
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: float
  states: {}
- name: analog_noise_source_x_0_0
  id: analog_noise_source_x
  parameters:
    amp: amp[1]
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: float
  states: {}
- name: analog_noise_source_x_0_0_0
  id: analog_noise_source_x
  parameters:
    amp: amp[2]
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: float
  states: {}
- name: analog_noise_source_x_0_0_1
  id: analog_noise_source_x
  parameters:
    amp: amp[3]
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: float
  states: {}
- name: analog_noise_source_x_0_0_1_0
  id: analog_noise_source_x
  parameters:
    amp: amp[4]
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: float
  states: {}
- name: analog_noise_source_x_0_0_1_1
  id: analog_noise_source_x
  parameters:
    amp: amp[5]
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: float
  states: {}
- name: analog_noise_source_x_0_0_1_2
  id: analog_noise_source_x
  parameters:
    amp: amp[6]
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: float
  states: {}
- name: analog_noise_source_x_0_0_1_3
  id: analog_noise_source_x
  parameters:
    amp: amp[7]
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: float
  states: {}
- name: analog_noise_source_x_0_0_1_4
  id: analog_noise_source_x
  parameters:
    amp: amp[8]
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: float
  states: {}
- name: analog_noise_source_x_0_0_1_5
  id: analog_noise_source_x
  parameters:
    amp: amp[9]
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: float
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '2'
    min: '0'
    num_samps: '10000'
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: blocks_add_const_vxx_0_0
  id: blocks_add_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: blocks_add_const_vxx_0_0_0
  id: blocks_add_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: blocks_add_const_vxx_0_0_1
  id: blocks_add_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: blocks_add_const_vxx_0_0_1_0
  id: blocks_add_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: blocks_add_const_vxx_0_0_1_1
  id: blocks_add_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: blocks_add_const_vxx_0_0_1_2
  id: blocks_add_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: blocks_add_const_vxx_0_0_1_3
  id: blocks_add_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: blocks_add_const_vxx_0_0_1_4
  id: blocks_add_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: blocks_add_const_vxx_0_0_1_5
  id: blocks_add_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: blocks_add_xx_1
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_add_xx_1_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_add_xx_1_0_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_add_xx_1_0_1
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_add_xx_1_0_1_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_add_xx_1_0_1_1
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_add_xx_1_0_1_2
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_add_xx_1_0_1_3
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_add_xx_1_0_1_4
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_add_xx_1_0_1_5
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '0.5'
  states: {}
- name: blocks_char_to_float_0_0
  id: blocks_char_to_float
  parameters:
    scale: '0.5'
  states: {}
- name: blocks_char_to_float_0_0_0
  id: blocks_char_to_float
  parameters:
    scale: '0.5'
  states: {}
- name: blocks_char_to_float_0_0_1
  id: blocks_char_to_float
  parameters:
    scale: '0.5'
  states: {}
- name: blocks_char_to_float_0_0_1_0
  id: blocks_char_to_float
  parameters:
    scale: '0.5'
  states: {}
- name: blocks_char_to_float_0_0_1_1
  id: blocks_char_to_float
  parameters:
    scale: '0.5'
  states: {}
- name: blocks_char_to_float_0_0_1_2
  id: blocks_char_to_float
  parameters:
    scale: '0.5'
  states: {}
- name: blocks_char_to_float_0_0_1_3
  id: blocks_char_to_float
  parameters:
    scale: '0.5'
  states: {}
- name: blocks_char_to_float_0_0_1_4
  id: blocks_char_to_float
  parameters:
    scale: '0.5'
  states: {}
- name: blocks_char_to_float_0_0_1_5
  id: blocks_char_to_float
  parameters:
    scale: '0.5'
  states: {}
- name: blocks_char_to_float_0_1
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_binary_slicer_fb_0_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_binary_slicer_fb_0_0_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_binary_slicer_fb_0_0_0_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_binary_slicer_fb_0_0_0_0_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_binary_slicer_fb_0_0_0_0_0_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_binary_slicer_fb_0_0_0_0_0_0_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_binary_slicer_fb_0_0_0_0_0_0_0_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_binary_slicer_fb_0_0_0_0_0_0_0_0_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_binary_slicer_fb_0_0_0_0_0_0_0_0_0_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from math import log10
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: qtgui_bercurve_sink_0
  id: qtgui_bercurve_sink
  parameters:
    berlimit: '-8.0'
    berminerrors: '1000'
    esno: esno
    label1: Hard Decoding
    label2: Soft Decoding
    label3: Uncoded
    num_curves: num_curves
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: msg
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: soft_1
  states: {}
- name: virtual_sink_0_0_0
  id: virtual_sink
  parameters:
    stream_id: hard_1
  states: {}
- name: virtual_sink_0_0_0_0
  id: virtual_sink
  parameters:
    stream_id: hard_2
  states: {}
- name: virtual_sink_0_0_0_0_0
  id: virtual_sink
  parameters:
    stream_id: hard_3
  states: {}
- name: virtual_sink_0_0_0_0_1
  id: virtual_sink
  parameters:
    stream_id: hard_4
  states: {}
- name: virtual_sink_0_0_0_0_1_0
  id: virtual_sink
  parameters:
    stream_id: hard_5
  states: {}
- name: virtual_sink_0_0_0_0_1_1
  id: virtual_sink
  parameters:
    stream_id: hard_6
  states: {}
- name: virtual_sink_0_0_0_0_1_2
  id: virtual_sink
  parameters:
    stream_id: hard_7
  states: {}
- name: virtual_sink_0_0_0_0_1_3
  id: virtual_sink
  parameters:
    stream_id: hard_8
  states: {}
- name: virtual_sink_0_0_0_0_1_4
  id: virtual_sink
  parameters:
    stream_id: hard_9
  states: {}
- name: virtual_sink_0_0_0_0_1_5
  id: virtual_sink
  parameters:
    stream_id: hard_10
  states: {}
- name: virtual_sink_0_0_0_1
  id: virtual_sink
  parameters:
    stream_id: uncoded_1
  states: {}
- name: virtual_sink_0_0_0_1_0
  id: virtual_sink
  parameters:
    stream_id: uncoded_2
  states: {}
- name: virtual_sink_0_0_0_1_1
  id: virtual_sink
  parameters:
    stream_id: uncoded_3
  states: {}
- name: virtual_sink_0_0_0_1_2
  id: virtual_sink
  parameters:
    stream_id: uncoded_4
  states: {}
- name: virtual_sink_0_0_0_1_3
  id: virtual_sink
  parameters:
    stream_id: uncoded_5
  states: {}
- name: virtual_sink_0_0_0_1_4
  id: virtual_sink
  parameters:
    stream_id: uncoded_6
  states: {}
- name: virtual_sink_0_0_0_1_5
  id: virtual_sink
  parameters:
    stream_id: uncoded_7
  states: {}
- name: virtual_sink_0_0_0_1_6
  id: virtual_sink
  parameters:
    stream_id: uncoded_8
  states: {}
- name: virtual_sink_0_0_0_1_7
  id: virtual_sink
  parameters:
    stream_id: uncoded_9
  states: {}
- name: virtual_sink_0_0_0_1_8
  id: virtual_sink
  parameters:
    stream_id: uncoded_10
  states: {}
- name: virtual_sink_0_0_1
  id: virtual_sink
  parameters:
    stream_id: soft_2
  states: {}
- name: virtual_sink_0_0_1_0
  id: virtual_sink
  parameters:
    stream_id: soft_3
  states: {}
- name: virtual_sink_0_0_1_1
  id: virtual_sink
  parameters:
    stream_id: soft_4
  states: {}
- name: virtual_sink_0_0_1_1_0
  id: virtual_sink
  parameters:
    stream_id: soft_5
  states: {}
- name: virtual_sink_0_0_1_1_1
  id: virtual_sink
  parameters:
    stream_id: soft_6
  states: {}
- name: virtual_sink_0_0_1_1_2
  id: virtual_sink
  parameters:
    stream_id: soft_7
  states: {}
- name: virtual_sink_0_0_1_1_3
  id: virtual_sink
  parameters:
    stream_id: soft_8
  states: {}
- name: virtual_sink_0_0_1_1_4
  id: virtual_sink
  parameters:
    stream_id: soft_9
  states: {}
- name: virtual_sink_0_0_1_1_5
  id: virtual_sink
  parameters:
    stream_id: soft_10
  states: {}
- name: virtual_sink_0_1
  id: virtual_sink
  parameters:
    stream_id: encoded
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: msg
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: hard_1
  states: {}
- name: virtual_source_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: soft_1
  states: {}
- name: virtual_source_0_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: uncoded_1
  states: {}
- name: virtual_source_0_1
  id: virtual_source
  parameters:
    stream_id: hard_2
  states: {}
- name: virtual_source_0_1_0
  id: virtual_source
  parameters:
    stream_id: hard_3
  states: {}
- name: virtual_source_0_1_0_0_0
  id: virtual_source
  parameters:
    stream_id: soft_3
  states: {}
- name: virtual_source_0_1_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: uncoded_3
  states: {}
- name: virtual_source_0_1_1
  id: virtual_source
  parameters:
    stream_id: hard_4
  states: {}
- name: virtual_source_0_1_1_0_0
  id: virtual_source
  parameters:
    stream_id: soft_4
  states: {}
- name: virtual_source_0_1_1_0_0_0
  id: virtual_source
  parameters:
    stream_id: uncoded_4
  states: {}
- name: virtual_source_0_1_2
  id: virtual_source
  parameters:
    stream_id: hard_5
  states: {}
- name: virtual_source_0_1_2_0_0
  id: virtual_source
  parameters:
    stream_id: soft_5
  states: {}
- name: virtual_source_0_1_2_0_0_0
  id: virtual_source
  parameters:
    stream_id: uncoded_5
  states: {}
- name: virtual_source_0_1_3
  id: virtual_source
  parameters:
    stream_id: hard_6
  states: {}
- name: virtual_source_0_1_3_0_0
  id: virtual_source
  parameters:
    stream_id: soft_6
  states: {}
- name: virtual_source_0_1_3_0_0_0
  id: virtual_source
  parameters:
    stream_id: uncoded_6
  states: {}
- name: virtual_source_0_1_4
  id: virtual_source
  parameters:
    stream_id: hard_7
  states: {}
- name: virtual_source_0_1_4_0_0
  id: virtual_source
  parameters:
    stream_id: soft_7
  states: {}
- name: virtual_source_0_1_4_0_0_0
  id: virtual_source
  parameters:
    stream_id: uncoded_7
  states: {}
- name: virtual_source_0_1_5
  id: virtual_source
  parameters:
    stream_id: hard_8
  states: {}
- name: virtual_source_0_1_5_0
  id: virtual_source
  parameters:
    stream_id: hard_9
  states: {}
- name: virtual_source_0_1_5_0_0_0
  id: virtual_source
  parameters:
    stream_id: soft_9
  states: {}
- name: virtual_source_0_1_5_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: uncoded_9
  states: {}
- name: virtual_source_0_1_5_1
  id: virtual_source
  parameters:
    stream_id: hard_10
  states: {}
- name: virtual_source_0_1_5_1_0_0
  id: virtual_source
  parameters:
    stream_id: soft_10
  states: {}
- name: virtual_source_0_1_5_1_0_0_0
  id: virtual_source
  parameters:
    stream_id: uncoded_10
  states: {}
- name: virtual_source_0_1_5_2_0
  id: virtual_source
  parameters:
    stream_id: soft_8
  states: {}
- name: virtual_source_0_1_5_2_0_0
  id: virtual_source
  parameters:
    stream_id: uncoded_8
  states: {}
- name: virtual_source_0_1_6_0
  id: virtual_source
  parameters:
    stream_id: soft_2
  states: {}
- name: virtual_source_0_1_6_0_0
  id: virtual_source
  parameters:
    stream_id: uncoded_2
  states: {}
- name: virtual_source_0_2
  id: virtual_source
  parameters:
    stream_id: msg
  states: {}
- name: virtual_source_0_2_0
  id: virtual_source
  parameters:
    stream_id: msg
  states: {}
- name: virtual_source_0_2_0_0_0
  id: virtual_source
  parameters:
    stream_id: msg
  states: {}
- name: virtual_source_0_2_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: msg
  states: {}
- name: virtual_source_0_2_1
  id: virtual_source
  parameters:
    stream_id: msg
  states: {}
- name: virtual_source_0_2_1_0_0
  id: virtual_source
  parameters:
    stream_id: msg
  states: {}
- name: virtual_source_0_2_1_0_0_0
  id: virtual_source
  parameters:
    stream_id: msg
  states: {}
- name: virtual_source_0_2_2
  id: virtual_source
  parameters:
    stream_id: msg
  states: {}
- name: virtual_source_0_2_2_0_0
  id: virtual_source
  parameters:
    stream_id: msg
  states: {}
- name: virtual_source_0_2_2_0_0_0
  id: virtual_source
  parameters:
    stream_id: msg
  states: {}
- name: virtual_source_0_2_3
  id: virtual_source
  parameters:
    stream_id: msg
  states: {}
- name: virtual_source_0_2_3_0_0
  id: virtual_source
  parameters:
    stream_id: msg
  states: {}
- name: virtual_source_0_2_3_0_0_0
  id: virtual_source
  parameters:
    stream_id: msg
  states: {}
- name: virtual_source_0_2_4
  id: virtual_source
  parameters:
    stream_id: msg
  states: {}
- name: virtual_source_0_2_4_0_0
  id: virtual_source
  parameters:
    stream_id: msg
  states: {}
- name: virtual_source_0_2_4_0_0_0
  id: virtual_source
  parameters:
    stream_id: msg
  states: {}
- name: virtual_source_0_2_5
  id: virtual_source
  parameters:
    stream_id: msg
  states: {}
- name: virtual_source_0_2_5_0
  id: virtual_source
  parameters:
    stream_id: msg
  states: {}
- name: virtual_source_0_2_5_0_0_0
  id: virtual_source
  parameters:
    stream_id: msg
  states: {}
- name: virtual_source_0_2_5_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: msg
  states: {}
- name: virtual_source_0_2_5_1
  id: virtual_source
  parameters:
    stream_id: msg
  states: {}
- name: virtual_source_0_2_5_1_0_0
  id: virtual_source
  parameters:
    stream_id: msg
  states: {}
- name: virtual_source_0_2_5_1_0_0_0
  id: virtual_source
  parameters:
    stream_id: msg
  states: {}
- name: virtual_source_0_2_5_1_0_0_1
  id: virtual_source
  parameters:
    stream_id: msg
  states: {}
- name: virtual_source_0_2_5_2_0
  id: virtual_source
  parameters:
    stream_id: msg
  states: {}
- name: virtual_source_0_2_5_2_0_0
  id: virtual_source
  parameters:
    stream_id: msg
  states: {}
- name: virtual_source_0_2_6_0
  id: virtual_source
  parameters:
    stream_id: msg
  states: {}
- name: virtual_source_0_2_6_0_0
  id: virtual_source
  parameters:
    stream_id: msg
  states: {}
- name: virtual_source_0_3
  id: virtual_source
  parameters:
    stream_id: encoded
  states: {}
- name: virtual_source_0_3_0
  id: virtual_source
  parameters:
    stream_id: encoded
  states: {}
- name: virtual_source_0_3_0_0
  id: virtual_source
  parameters:
    stream_id: encoded
  states: {}
- name: virtual_source_0_3_0_0_0
  id: virtual_source
  parameters:
    stream_id: encoded
  states: {}
- name: virtual_source_0_3_0_0_1
  id: virtual_source
  parameters:
    stream_id: encoded
  states: {}
- name: virtual_source_0_3_0_0_2
  id: virtual_source
  parameters:
    stream_id: encoded
  states: {}
- name: virtual_source_0_3_0_0_3
  id: virtual_source
  parameters:
    stream_id: encoded
  states: {}
- name: virtual_source_0_3_0_0_4
  id: virtual_source
  parameters:
    stream_id: encoded
  states: {}
- name: virtual_source_0_3_0_0_5
  id: virtual_source
  parameters:
    stream_id: encoded
  states: {}
- name: virtual_source_0_4_0
  id: virtual_source
  parameters:
    stream_id: msg
  states: {}

connections:
- [ITpp_Decoder_BPSK_0, '0', virtual_sink_0_0_0_1, '0']
- [ITpp_Decoder_BPSK_0_0, '0', virtual_sink_0_0_0_1_0, '0']
- [ITpp_Decoder_BPSK_0_1, '0', virtual_sink_0_0_0_1_1, '0']
- [ITpp_Decoder_BPSK_0_2, '0', virtual_sink_0_0_0_1_2, '0']
- [ITpp_Decoder_BPSK_0_3, '0', virtual_sink_0_0_0_1_3, '0']
- [ITpp_Decoder_BPSK_0_4, '0', virtual_sink_0_0_0_1_4, '0']
- [ITpp_Decoder_BPSK_0_5, '0', virtual_sink_0_0_0_1_5, '0']
- [ITpp_Decoder_BPSK_0_6, '0', virtual_sink_0_0_0_1_6, '0']
- [ITpp_Decoder_BPSK_0_7, '0', virtual_sink_0_0_0_1_7, '0']
- [ITpp_Decoder_BPSK_0_8, '0', virtual_sink_0_0_0_1_8, '0']
- [ITpp_Hamming_Decoder_0, '0', virtual_sink_0_0_0, '0']
- [ITpp_Hamming_Decoder_0_0, '0', virtual_sink_0_0_0_0, '0']
- [ITpp_Hamming_Decoder_0_0_0, '0', virtual_sink_0_0_0_0_0, '0']
- [ITpp_Hamming_Decoder_0_0_1, '0', virtual_sink_0_0_0_0_1, '0']
- [ITpp_Hamming_Decoder_0_0_1_0, '0', virtual_sink_0_0_0_0_1_0, '0']
- [ITpp_Hamming_Decoder_0_0_1_1, '0', virtual_sink_0_0_0_0_1_1, '0']
- [ITpp_Hamming_Decoder_0_0_1_2, '0', virtual_sink_0_0_0_0_1_2, '0']
- [ITpp_Hamming_Decoder_0_0_1_3, '0', virtual_sink_0_0_0_0_1_3, '0']
- [ITpp_Hamming_Decoder_0_0_1_4, '0', virtual_sink_0_0_0_0_1_4, '0']
- [ITpp_Hamming_Decoder_0_0_1_5, '0', virtual_sink_0_0_0_0_1_5, '0']
- [ITpp_Hamming_Encoder_0, '0', blocks_char_to_float_0, '0']
- [ITpp_Hamming_Encoder_0, '0', virtual_sink_0_1, '0']
- [ITpp_Hamming_Soft_Decoder_0, '0', virtual_sink_0_0, '0']
- [ITpp_Hamming_Soft_Decoder_0_0, '0', virtual_sink_0_0_1, '0']
- [ITpp_Hamming_Soft_Decoder_0_0_0, '0', virtual_sink_0_0_1_0, '0']
- [ITpp_Hamming_Soft_Decoder_0_0_1, '0', virtual_sink_0_0_1_1, '0']
- [ITpp_Hamming_Soft_Decoder_0_0_1_0, '0', virtual_sink_0_0_1_1_0, '0']
- [ITpp_Hamming_Soft_Decoder_0_0_1_1, '0', virtual_sink_0_0_1_1_1, '0']
- [ITpp_Hamming_Soft_Decoder_0_0_1_2, '0', virtual_sink_0_0_1_1_2, '0']
- [ITpp_Hamming_Soft_Decoder_0_0_1_3, '0', virtual_sink_0_0_1_1_3, '0']
- [ITpp_Hamming_Soft_Decoder_0_0_1_4, '0', virtual_sink_0_0_1_1_4, '0']
- [ITpp_Hamming_Soft_Decoder_0_0_1_5, '0', virtual_sink_0_0_1_1_5, '0']
- [analog_noise_source_x_0, '0', blocks_add_xx_1, '0']
- [analog_noise_source_x_0_0, '0', blocks_add_xx_1_0, '0']
- [analog_noise_source_x_0_0_0, '0', blocks_add_xx_1_0_0, '0']
- [analog_noise_source_x_0_0_1, '0', blocks_add_xx_1_0_1, '0']
- [analog_noise_source_x_0_0_1_0, '0', blocks_add_xx_1_0_1_0, '0']
- [analog_noise_source_x_0_0_1_1, '0', blocks_add_xx_1_0_1_1, '0']
- [analog_noise_source_x_0_0_1_2, '0', blocks_add_xx_1_0_1_2, '0']
- [analog_noise_source_x_0_0_1_3, '0', blocks_add_xx_1_0_1_3, '0']
- [analog_noise_source_x_0_0_1_4, '0', blocks_add_xx_1_0_1_4, '0']
- [analog_noise_source_x_0_0_1_5, '0', blocks_add_xx_1_0_1_5, '0']
- [analog_random_source_x_0, '0', blocks_throttle_0, '0']
- [blocks_add_const_vxx_0, '0', blocks_add_xx_1, '1']
- [blocks_add_const_vxx_0_0, '0', blocks_add_xx_1_0, '1']
- [blocks_add_const_vxx_0_0_0, '0', blocks_add_xx_1_0_0, '1']
- [blocks_add_const_vxx_0_0_1, '0', blocks_add_xx_1_0_1, '1']
- [blocks_add_const_vxx_0_0_1_0, '0', blocks_add_xx_1_0_1_0, '1']
- [blocks_add_const_vxx_0_0_1_1, '0', blocks_add_xx_1_0_1_1, '1']
- [blocks_add_const_vxx_0_0_1_2, '0', blocks_add_xx_1_0_1_2, '1']
- [blocks_add_const_vxx_0_0_1_3, '0', blocks_add_xx_1_0_1_3, '1']
- [blocks_add_const_vxx_0_0_1_4, '0', blocks_add_xx_1_0_1_4, '1']
- [blocks_add_const_vxx_0_0_1_5, '0', blocks_add_xx_1_0_1_5, '1']
- [blocks_add_xx_1, '0', ITpp_Hamming_Soft_Decoder_0, '0']
- [blocks_add_xx_1, '0', digital_binary_slicer_fb_0, '0']
- [blocks_add_xx_1_0, '0', ITpp_Hamming_Soft_Decoder_0_0, '0']
- [blocks_add_xx_1_0, '0', digital_binary_slicer_fb_0_0, '0']
- [blocks_add_xx_1_0_0, '0', ITpp_Hamming_Soft_Decoder_0_0_0, '0']
- [blocks_add_xx_1_0_0, '0', digital_binary_slicer_fb_0_0_0, '0']
- [blocks_add_xx_1_0_1, '0', ITpp_Hamming_Soft_Decoder_0_0_1, '0']
- [blocks_add_xx_1_0_1, '0', digital_binary_slicer_fb_0_0_0_0, '0']
- [blocks_add_xx_1_0_1_0, '0', ITpp_Hamming_Soft_Decoder_0_0_1_0, '0']
- [blocks_add_xx_1_0_1_0, '0', digital_binary_slicer_fb_0_0_0_0_0, '0']
- [blocks_add_xx_1_0_1_1, '0', ITpp_Hamming_Soft_Decoder_0_0_1_1, '0']
- [blocks_add_xx_1_0_1_1, '0', digital_binary_slicer_fb_0_0_0_0_0_0, '0']
- [blocks_add_xx_1_0_1_2, '0', ITpp_Hamming_Soft_Decoder_0_0_1_2, '0']
- [blocks_add_xx_1_0_1_2, '0', digital_binary_slicer_fb_0_0_0_0_0_0_0, '0']
- [blocks_add_xx_1_0_1_3, '0', ITpp_Hamming_Soft_Decoder_0_0_1_3, '0']
- [blocks_add_xx_1_0_1_3, '0', digital_binary_slicer_fb_0_0_0_0_0_0_0_0, '0']
- [blocks_add_xx_1_0_1_4, '0', ITpp_Hamming_Soft_Decoder_0_0_1_4, '0']
- [blocks_add_xx_1_0_1_4, '0', digital_binary_slicer_fb_0_0_0_0_0_0_0_0_0, '0']
- [blocks_add_xx_1_0_1_5, '0', ITpp_Hamming_Soft_Decoder_0_0_1_5, '0']
- [blocks_add_xx_1_0_1_5, '0', digital_binary_slicer_fb_0_0_0_0_0_0_0_0_0_0, '0']
- [blocks_char_to_float_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_char_to_float_0_0, '0', blocks_add_const_vxx_0_0, '0']
- [blocks_char_to_float_0_0_0, '0', blocks_add_const_vxx_0_0_0, '0']
- [blocks_char_to_float_0_0_1, '0', blocks_add_const_vxx_0_0_1, '0']
- [blocks_char_to_float_0_0_1_0, '0', blocks_add_const_vxx_0_0_1_0, '0']
- [blocks_char_to_float_0_0_1_1, '0', blocks_add_const_vxx_0_0_1_1, '0']
- [blocks_char_to_float_0_0_1_2, '0', blocks_add_const_vxx_0_0_1_2, '0']
- [blocks_char_to_float_0_0_1_3, '0', blocks_add_const_vxx_0_0_1_3, '0']
- [blocks_char_to_float_0_0_1_4, '0', blocks_add_const_vxx_0_0_1_4, '0']
- [blocks_char_to_float_0_0_1_5, '0', blocks_add_const_vxx_0_0_1_5, '0']
- [blocks_char_to_float_0_1, '0', qtgui_time_sink_x_0, '0']
- [blocks_throttle_0, '0', ITpp_Hamming_Encoder_0, '0']
- [blocks_throttle_0, '0', blocks_char_to_float_0_1, '0']
- [blocks_throttle_0, '0', virtual_sink_0, '0']
- [digital_binary_slicer_fb_0, '0', ITpp_Decoder_BPSK_0, '0']
- [digital_binary_slicer_fb_0, '0', ITpp_Hamming_Decoder_0, '0']
- [digital_binary_slicer_fb_0_0, '0', ITpp_Decoder_BPSK_0_0, '0']
- [digital_binary_slicer_fb_0_0, '0', ITpp_Hamming_Decoder_0_0, '0']
- [digital_binary_slicer_fb_0_0_0, '0', ITpp_Decoder_BPSK_0_1, '0']
- [digital_binary_slicer_fb_0_0_0, '0', ITpp_Hamming_Decoder_0_0_0, '0']
- [digital_binary_slicer_fb_0_0_0_0, '0', ITpp_Decoder_BPSK_0_2, '0']
- [digital_binary_slicer_fb_0_0_0_0, '0', ITpp_Hamming_Decoder_0_0_1, '0']
- [digital_binary_slicer_fb_0_0_0_0_0, '0', ITpp_Decoder_BPSK_0_3, '0']
- [digital_binary_slicer_fb_0_0_0_0_0, '0', ITpp_Hamming_Decoder_0_0_1_0, '0']
- [digital_binary_slicer_fb_0_0_0_0_0_0, '0', ITpp_Decoder_BPSK_0_4, '0']
- [digital_binary_slicer_fb_0_0_0_0_0_0, '0', ITpp_Hamming_Decoder_0_0_1_1, '0']
- [digital_binary_slicer_fb_0_0_0_0_0_0_0, '0', ITpp_Decoder_BPSK_0_5, '0']
- [digital_binary_slicer_fb_0_0_0_0_0_0_0, '0', ITpp_Hamming_Decoder_0_0_1_2, '0']
- [digital_binary_slicer_fb_0_0_0_0_0_0_0_0, '0', ITpp_Decoder_BPSK_0_6, '0']
- [digital_binary_slicer_fb_0_0_0_0_0_0_0_0, '0', ITpp_Hamming_Decoder_0_0_1_3, '0']
- [digital_binary_slicer_fb_0_0_0_0_0_0_0_0_0, '0', ITpp_Decoder_BPSK_0_7, '0']
- [digital_binary_slicer_fb_0_0_0_0_0_0_0_0_0, '0', ITpp_Hamming_Decoder_0_0_1_4, '0']
- [digital_binary_slicer_fb_0_0_0_0_0_0_0_0_0_0, '0', ITpp_Decoder_BPSK_0_8, '0']
- [digital_binary_slicer_fb_0_0_0_0_0_0_0_0_0_0, '0', ITpp_Hamming_Decoder_0_0_1_5, '0']
- [virtual_source_0, '0', qtgui_bercurve_sink_0, '0']
- [virtual_source_0_0, '0', qtgui_bercurve_sink_0, '1']
- [virtual_source_0_0_0_0, '0', qtgui_bercurve_sink_0, '21']
- [virtual_source_0_0_0_0_0, '0', qtgui_bercurve_sink_0, '41']
- [virtual_source_0_1, '0', qtgui_bercurve_sink_0, '3']
- [virtual_source_0_1_0, '0', qtgui_bercurve_sink_0, '5']
- [virtual_source_0_1_0_0_0, '0', qtgui_bercurve_sink_0, '25']
- [virtual_source_0_1_0_0_0_0, '0', qtgui_bercurve_sink_0, '45']
- [virtual_source_0_1_1, '0', qtgui_bercurve_sink_0, '7']
- [virtual_source_0_1_1_0_0, '0', qtgui_bercurve_sink_0, '27']
- [virtual_source_0_1_1_0_0_0, '0', qtgui_bercurve_sink_0, '47']
- [virtual_source_0_1_2, '0', qtgui_bercurve_sink_0, '9']
- [virtual_source_0_1_2_0_0, '0', qtgui_bercurve_sink_0, '29']
- [virtual_source_0_1_2_0_0_0, '0', qtgui_bercurve_sink_0, '49']
- [virtual_source_0_1_3, '0', qtgui_bercurve_sink_0, '11']
- [virtual_source_0_1_3_0_0, '0', qtgui_bercurve_sink_0, '31']
- [virtual_source_0_1_3_0_0_0, '0', qtgui_bercurve_sink_0, '51']
- [virtual_source_0_1_4, '0', qtgui_bercurve_sink_0, '13']
- [virtual_source_0_1_4_0_0, '0', qtgui_bercurve_sink_0, '33']
- [virtual_source_0_1_4_0_0_0, '0', qtgui_bercurve_sink_0, '53']
- [virtual_source_0_1_5, '0', qtgui_bercurve_sink_0, '15']
- [virtual_source_0_1_5_0, '0', qtgui_bercurve_sink_0, '17']
- [virtual_source_0_1_5_0_0_0, '0', qtgui_bercurve_sink_0, '37']
- [virtual_source_0_1_5_0_0_0_0, '0', qtgui_bercurve_sink_0, '57']
- [virtual_source_0_1_5_1, '0', qtgui_bercurve_sink_0, '19']
- [virtual_source_0_1_5_1_0_0, '0', qtgui_bercurve_sink_0, '39']
- [virtual_source_0_1_5_1_0_0_0, '0', qtgui_bercurve_sink_0, '59']
- [virtual_source_0_1_5_2_0, '0', qtgui_bercurve_sink_0, '35']
- [virtual_source_0_1_5_2_0_0, '0', qtgui_bercurve_sink_0, '55']
- [virtual_source_0_1_6_0, '0', qtgui_bercurve_sink_0, '23']
- [virtual_source_0_1_6_0_0, '0', qtgui_bercurve_sink_0, '43']
- [virtual_source_0_2, '0', qtgui_bercurve_sink_0, '2']
- [virtual_source_0_2_0, '0', qtgui_bercurve_sink_0, '4']
- [virtual_source_0_2_0_0_0, '0', qtgui_bercurve_sink_0, '24']
- [virtual_source_0_2_0_0_0_0, '0', qtgui_bercurve_sink_0, '44']
- [virtual_source_0_2_1, '0', qtgui_bercurve_sink_0, '6']
- [virtual_source_0_2_1_0_0, '0', qtgui_bercurve_sink_0, '26']
- [virtual_source_0_2_1_0_0_0, '0', qtgui_bercurve_sink_0, '46']
- [virtual_source_0_2_2, '0', qtgui_bercurve_sink_0, '8']
- [virtual_source_0_2_2_0_0, '0', qtgui_bercurve_sink_0, '28']
- [virtual_source_0_2_2_0_0_0, '0', qtgui_bercurve_sink_0, '48']
- [virtual_source_0_2_3, '0', qtgui_bercurve_sink_0, '10']
- [virtual_source_0_2_3_0_0, '0', qtgui_bercurve_sink_0, '30']
- [virtual_source_0_2_3_0_0_0, '0', qtgui_bercurve_sink_0, '50']
- [virtual_source_0_2_4, '0', qtgui_bercurve_sink_0, '12']
- [virtual_source_0_2_4_0_0, '0', qtgui_bercurve_sink_0, '32']
- [virtual_source_0_2_4_0_0_0, '0', qtgui_bercurve_sink_0, '52']
- [virtual_source_0_2_5, '0', qtgui_bercurve_sink_0, '14']
- [virtual_source_0_2_5_0, '0', qtgui_bercurve_sink_0, '16']
- [virtual_source_0_2_5_0_0_0, '0', qtgui_bercurve_sink_0, '36']
- [virtual_source_0_2_5_0_0_0_0, '0', qtgui_bercurve_sink_0, '56']
- [virtual_source_0_2_5_1, '0', qtgui_bercurve_sink_0, '18']
- [virtual_source_0_2_5_1_0_0, '0', qtgui_bercurve_sink_0, '38']
- [virtual_source_0_2_5_1_0_0_0, '0', qtgui_bercurve_sink_0, '58']
- [virtual_source_0_2_5_1_0_0_1, '0', qtgui_bercurve_sink_0, '40']
- [virtual_source_0_2_5_2_0, '0', qtgui_bercurve_sink_0, '34']
- [virtual_source_0_2_5_2_0_0, '0', qtgui_bercurve_sink_0, '54']
- [virtual_source_0_2_6_0, '0', qtgui_bercurve_sink_0, '22']
- [virtual_source_0_2_6_0_0, '0', qtgui_bercurve_sink_0, '42']
- [virtual_source_0_3, '0', blocks_char_to_float_0_0, '0']
- [virtual_source_0_3_0, '0', blocks_char_to_float_0_0_0, '0']
- [virtual_source_0_3_0_0, '0', blocks_char_to_float_0_0_1, '0']
- [virtual_source_0_3_0_0_0, '0', blocks_char_to_float_0_0_1_0, '0']
- [virtual_source_0_3_0_0_1, '0', blocks_char_to_float_0_0_1_1, '0']
- [virtual_source_0_3_0_0_2, '0', blocks_char_to_float_0_0_1_2, '0']
- [virtual_source_0_3_0_0_3, '0', blocks_char_to_float_0_0_1_3, '0']
- [virtual_source_0_3_0_0_4, '0', blocks_char_to_float_0_0_1_4, '0']
- [virtual_source_0_3_0_0_5, '0', blocks_char_to_float_0_0_1_5, '0']
- [virtual_source_0_4_0, '0', qtgui_bercurve_sink_0, '20']

metadata:
  file_format: 1
