options:
  parameters:
    generate_options: qt_gui
    id: Hamming_decoder
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '320000'
  states: {}
- name: ITpp_BSC_Byte_0
  id: ITpp_BSC_Byte
  parameters:
    bits: '1'
    probability: '0.00786'
  states: {}
- name: ITpp_Hamming_Decoder_0
  id: ITpp_Hamming_Decoder
  parameters:
    m: '3'
  states: {}
- name: ITpp_Hamming_Encoder_0
  id: ITpp_Hamming_Encoder
  parameters:
    m: '3'
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_tags_strobe_0
  id: blocks_tags_strobe
  parameters:
    key: pmt.intern("")
    nsamps: '4'
    type: float
    value: pmt.intern("")
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_uchar_to_float_1
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: (1,1,1,0)
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    label1: Decodificado
    name: '"Decodificado Hamming"'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    label1: Enviado
    name: '"Sinal Enviado"'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [ITpp_BSC_Byte_0, '0', ITpp_Hamming_Decoder_0, '0']
- [ITpp_Hamming_Decoder_0, '0', blocks_uchar_to_float_0, '0']
- [ITpp_Hamming_Encoder_0, '0', ITpp_BSC_Byte_0, '0']
- [blocks_add_xx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_tags_strobe_0, '0', blocks_add_xx_0, '1']
- [blocks_throttle_0, '0', ITpp_Hamming_Encoder_0, '0']
- [blocks_throttle_0, '0', blocks_uchar_to_float_1, '0']
- [blocks_uchar_to_float_0, '0', blocks_add_xx_0, '0']
- [blocks_uchar_to_float_1, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_vector_source_x_0, '0', blocks_throttle_0, '0']

metadata:
  file_format: 1
